# Keil uVision project zw_project.uvproj, settings and files
target Fingerprint entrance guard (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: zw_project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Fingerprint entrance guard
    ./src/: DS18B20.c LCD12864.c main.c main_function.c ZW_SZM201.c
